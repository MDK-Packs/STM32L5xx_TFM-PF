# Keil uVision project tfm_ns.uvprojx, settings and files
target STM32L562E-DK (6150000::V6.15::ARMCLANG)
  device: STM32L562QEIxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x30000000,0x00040000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: tfm_ns
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wno-implicit-function-declaration
  memory RVCT4: ROM 0x8040000 size 0x30000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20020000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x40000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L562QEIxQ/STCubeGenerated/Src/: main.c stm32l5xx_it.c
    ./RTE/Device/STM32L562QEIxQ/STCubeGenerated/Inc/: stm32l5xx_it.h
  group CSME_Lib
    ../tfm_s/Objects/: tfm_s_CMSE_Lib.o
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, TFM:API:Audit Logging 1.2.0, TFM:API:Crypto 1.2.0, TFM:API:Initial Attestation 1.2.0, TFM:API:Internal Trusted Storage 1.2.0, TFM:API:Platform 1.2.0, TFM:API:Protected Storage 1.2.0, TFM:Core 1.2.0, TFM:Library:QCBOR 1.2.0, TFM:Library:T_COSE 1.2.0, TFM:Test:Attestation 1.2.0, TFM:Test:Audit 1.2.0, TFM:Test:Core Positive 1.2.0, TFM:Test:Crypto 1.2.0, TFM:Test:Framework 1.2.0, TFM:Test:ITS 1.2.0, TFM:Test:PS 1.0.0, TFM:Test:Platform 1.2.0, TFM:Test:QCBOR 1.2.0, TFM:Test:Secure Client 1.2.0, TFM:Test:T_COSE 1.2.0, CMSIS Driver:USART 1.0.0, Device:STM32Cube HAL:Common 1.0.3, Device:STM32Cube HAL:Cortex 1.0.3, Device:STM32Cube HAL:DMA 1.0.3, Device:STM32Cube HAL:Flash 1.0.3, Device:STM32Cube HAL:GPIO 1.0.3, Device:STM32Cube HAL:ICACHE 1.0.3, Device:STM32Cube HAL:IRDA 1.0.3, Device:STM32Cube HAL:PWR 1.0.3, Device:STM32Cube HAL:RCC 1.0.3, Device:STM32Cube HAL:Smartcard 1.0.3, Device:STM32Cube HAL:UART 1.0.3, Device:STM32Cube HAL:USART 1.0.3, Device:Startup 1.0.3
