# Keil uVision project tfm_s.uvprojx, settings and files
target STM32L562E-DK (6150000::V6.15::ARMCLANG)
  device: STM32L562QEIxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x30000000,0x00040000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: tfm_s
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\mbedTLS_HW\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: .\RTE\TFM\tfm_common_s.sct
  link misc: --import_cmse_lib_out="Objects/tfm_s_CMSE_Lib.o"
--predefine="-include tfm_config.h"
--predefine="-include tfm_config_rte.h"
--predefine="-IRTE/_STM32L562E-DK/"
--predefine="-IRTE/TFM_Platform/STM32L562QEIxQ/"
--diag_suppress=L6312,L6314,L6329
  group System Code
    ./: Driver_Flash.c Driver_USART.c
  group mbedTLS HW
    ./mbedTLS_HW/Src/: aes_alt.c ccm_alt.c ecdsa_alt.c ecp_alt.c ecp_curves_alt.c gcm_alt.c md5_alt.c rsa_alt.c sha256_alt.c low_level_rng.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L562QEIxQ/STCubeGenerated/Src/: main.c stm32l5xx_it.c
    ./RTE/Device/STM32L562QEIxQ/STCubeGenerated/Inc/: stm32l5xx_it.h
software components: CMSIS Driver:Flash:Custom 1.0.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.4.0, Security:mbed TLS 2.24.0, TFM Platform:Attest HAL:Template 1.2.0, TFM Platform:Boot Seed:Dummy 1.2.0, TFM Platform:Crypto Keys:Dummy 1.2.0, TFM Platform:Device ID:Dummy 1.2.0, TFM Platform:NV Counters:Dummy 1.2.0, TFM:Core 1.2.0, TFM:Library:QCBOR 1.2.0, TFM:Library:T_COSE 1.2.0, TFM:Secure Service:Audit Logging 1.2.0, TFM:Secure Service:Crypto 1.2.0, TFM:Secure Service:Initial Attestation 1.2.0, TFM:Secure Service:Internal Trusted Storage 1.2.0, TFM:Secure Service:Platform 1.2.0, TFM:Secure Service:Protected Storage 1.2.0, TFM:Test Service:Core 1.2.0, TFM:Test Service:IRQ 1.2.0, TFM:Test Service:PS 1.2.0, TFM:Test Service:Secure Client 1.2.0, TFM:Test:Attestation 1.2.0, TFM:Test:Audit 1.2.0, TFM:Test:Crypto 1.2.0, TFM:Test:Framework 1.2.0, TFM:Test:ITS 1.2.0, TFM:Test:PS 1.2.0, TFM:Test:Platform 1.2.0, Device:STM32Cube HAL:CRYP 1.0.3, Device:STM32Cube HAL:Common 1.0.3, Device:STM32Cube HAL:Cortex 1.0.3, Device:STM32Cube HAL:DMA 1.0.3, Device:STM32Cube HAL:Flash 1.0.3, Device:STM32Cube HAL:GPIO 1.0.3, Device:STM32Cube HAL:GTZC 1.0.3, Device:STM32Cube HAL:HASH 1.0.3, Device:STM32Cube HAL:ICACHE 1.0.3, Device:STM32Cube HAL:PKA 1.0.3, Device:STM32Cube HAL:PWR 1.0.3, Device:STM32Cube HAL:RCC 1.0.3, Device:STM32Cube HAL:RNG 1.0.3, Device:STM32Cube HAL:UART 1.0.3, Device:Startup 1.0.3, TFM Platform:Memory Map 1.2.0, TFM Platform:SPM HAL:Platform 1.2.0, TFM Platform:System:Template 1.2.0, TFM Platform:Test:Platform 1.2.0
