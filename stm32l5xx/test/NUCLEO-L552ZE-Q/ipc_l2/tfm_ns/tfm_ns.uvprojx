# Keil uVision project tfm_ns.uvprojx, settings and files
target NUCLEO-L552ZE-Q (6140000::V6.14::ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x30000000,0x00040000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: tfm_ns
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8040000 size 0x30000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20020000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x40000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L552ZETxQ/STCubeGenerated/Src/: main.c stm32l5xx_it.c
    ./RTE/Device/STM32L552ZETxQ/STCubeGenerated/Inc/: stm32l5xx_it.h
  group CSME_Lib
    ../tfm_s/Objects/: tfm_s_CMSE_Lib.o
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, TFM:API 1.0.0, TFM:Library:QCBOR 1.0.0, TFM:Library:T_COSE 1.0.0, TFM:Test:Attestation 1.0.0, TFM:Test:Core Positive 1.0.0, TFM:Test:Crypto 1.0.0, TFM:Test:Framework 1.0.0, TFM:Test:IPC 1.0.0, TFM:Test:ITS 1.0.0, TFM:Test:Platform 1.0.0, TFM:Test:QCBOR 1.0.0, TFM:Test:SST 1.0.0, TFM:Test:Secure Client 1.0.0, TFM:Test:T_COSE 1.0.0, CMSIS Driver:USART 1.0.0, Device:STM32Cube HAL:Common 1.0.0, Device:STM32Cube HAL:Cortex 1.0.2, Device:STM32Cube HAL:DMA 1.0.2, Device:STM32Cube HAL:Flash 1.0.2, Device:STM32Cube HAL:GPIO 1.0.2, Device:STM32Cube HAL:ICACHE 1.0.2, Device:STM32Cube HAL:IRDA 1.0.2, Device:STM32Cube HAL:PWR 1.0.2, Device:STM32Cube HAL:RCC 1.0.2, Device:STM32Cube HAL:Smartcard 1.0.2, Device:STM32Cube HAL:UART 1.0.2, Device:STM32Cube HAL:USART 1.0.2, Device:Startup 1.0.2
