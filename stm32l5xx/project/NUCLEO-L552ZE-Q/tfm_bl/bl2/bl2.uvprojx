# Keil uVision project bl2.uvprojx, settings and files
target NUCLEO-L552ZE-Q (6140000::V6.14::ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x30000000,0x00040000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: bl2
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: .\RTE\Device\STM32L552ZETxQ\stm32l552xe_flash_s.sct
  group System Code
    ./: Driver_Flash.c Driver_USART.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L552ZETxQ/STCubeGenerated/Src/: main.c stm32l5xx_it.c
    ./RTE/Device/STM32L552ZETxQ/STCubeGenerated/Inc/: stm32l5xx_it.h
software components: CMSIS Driver:Flash:Custom 1.0.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.4.0, Security:mbed Crypto 3.0.1, TFM Platform:Crypto Keys:Dummy 1.0.0, TFM Platform:NV Counters:Dummy 1.0.0, TFM:Bootloader 1.0.0, Device:STM32Cube HAL:Common 1.0.0, Device:STM32Cube HAL:Cortex 1.0.2, Device:STM32Cube HAL:DMA 1.0.2, Device:STM32Cube HAL:Flash 1.0.2, Device:STM32Cube HAL:GPIO 1.0.2, Device:STM32Cube HAL:ICACHE 1.0.2, Device:STM32Cube HAL:PWR 1.0.2, Device:STM32Cube HAL:RCC 1.0.2, Device:STM32Cube HAL:UART 1.0.2, Device:Startup 1.0.2, TFM Platform:Boot HAL:Platform 1.0.0, TFM Platform:Memory Map 1.0.0
