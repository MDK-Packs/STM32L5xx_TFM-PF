# Keil uVision project tfm_ns.uvprojx, settings and files
target STM32L562E-DK (6140000::V6.14::ARMCLANG)
  device: STM32L562QEIxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x30000000,0x00040000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: tfm_ns
  AfterMake: image.bat
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8030400 size 0xf800
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20020000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x40000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L562QEIxQ/STCubeGenerated/Src/: main.c stm32l5xx_it.c
    ./RTE/Device/STM32L562QEIxQ/STCubeGenerated/Inc/: stm32l5xx_it.h
  group CSME_Lib
    ../tfm_s/Objects/: tfm_s_CMSE_Lib.o
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, TFM:API 1.0.0, Device:STM32Cube HAL:Common 1.0.0, Device:STM32Cube HAL:Cortex 1.0.2, Device:STM32Cube HAL:DMA 1.0.2, Device:STM32Cube HAL:Flash 1.0.2, Device:STM32Cube HAL:GPIO 1.0.2, Device:STM32Cube HAL:ICACHE 1.0.2, Device:STM32Cube HAL:PWR 1.0.2, Device:STM32Cube HAL:RCC 1.0.2, Device:Startup 1.0.2
